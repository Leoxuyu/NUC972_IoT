# Keil uVision project NUC972_IoT.uvproj, settings and files
target RTT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NUC972_IoT +hex
  AfterMake: fromelf --bin ".\build\Objects\@L.axf" --output ".\@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARM_LIBC
  c include: .\Core\Include;.\Libraries\Include;.\libcpu;.\rt-thread\include;.\rt-thread\components\drivers\include;..\NUC972_IoT_Program
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\Script\nuc970.sct
  link misc: --keep *.o(.rti_fn.*)
  group Applications
    ./Applications/: main.c
  group BSP
    ./BSP/: board.c interrupt.c reset.c rt_low_level_init.c SysTick.c drv_usart.c drv_eth.c drv_pin.c
  group Core
    ./Core/Source/: standalone.c sys.c sys_ebi.c sys_nuc970.s sys_timer.c sys_uart.c system_nuc970.c
  group Kernel
    ./rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group Libraries
    ./Libraries/Source/: 2d.c adc.c can.c cap.c crypto.c etimer.c fmi.c gpio.c i2c.c i2s.c jpegcodec.c lcd.c mtp.c pwm.c rtc.c sc.c scuart.c sdh.c spi.c uart.c usbd.c wwdt.c
  group ARM926
    ./libcpu/: cpuport.c mmu.c stack.c trap.c context_rvds.S start_rvds.S
  group DeviceDrivers
    ./rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ./rt-thread/components/drivers/serial/: serial.c
